Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-22T15:42:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Alternate UI 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 22 15:42:43 2020 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{B75D6BBF-CB96-4919-B7D8-D789B2CE3836}\ifc * Database version: 5507 * Database creation date: Tue Sep 22 15:42:42 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 22 15:42:42 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 22 15:42:42 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
Phase: П

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Категория: Сведения о проекте; Статус проекта: П

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Категория: Сведения о проекте; Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Статус проекта: П

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcFlowTerminal: 160х720, BIMLIB_Воронка_Fachmann_VMO:160х720:245677
In: Этаж 01
Material: Fachmann_ПВХ_Черный
Pset_ManufacturerTypeInformation - Manufacturer: Fachmann
Pset_DistributionFlowElementCommon - Reference: 160х720
Зависимости - Рабочая плоскость: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Отметка по умолчанию: 1219.2 mm
Идентификация - Марка: 21; ADSK_Версия семейства: 1; URL: https://fachmann-rus.ru/; Заголовок OmniClass: Roof Waste Water Drains; Изготовитель: Fachmann; Имя типа: 160х720; Номер OmniClass: 23.70.50.21.24.11; Описание: Обогреваемые кровельные воронки VMO 110x165, VMO 110x450, VMO 110x720, VMO 160x165, VMO 160x450, VMO 160x720 с листвоуловителем и металлическим прижимным фланцем для неэксплуатируемой кровли, с диаметром выпускного патрубка 110/160 мм, предназначена для отвода дождевой и талой воды с плоских кровель во внутренний водосток ливневой канализации. Листвоуловитель позволяет предотвратить попадание веток, листьев и прочего мусора в ливневую канализацию.; Производитель_Контакты: Email: all@fachmann-rus.ru; Тел: 8 (800) 511-07-21; Разработчик_Контакты: support@bimlib.pro
Механизмы - ADSK_Расход жидкости: 0 m3/s; Классификация систем: Не определено,Мощность; Fachmann_МаксимальныйРасход: 0.423776 m3/s
Прочее - Категория: Сантехнические приборы; Код типа: BIMLIB_Воронка_Fachmann_VMO: 160х720; Семейство: BIMLIB_Воронка_Fachmann_VMO: 160х720; Семейство и типоразмер: BIMLIB_Воронка_Fachmann_VMO: 160х720; Тип: BIMLIB_Воронка_Fachmann_VMO: 160х720; Уровень спецификации: Уровень: Этаж 01; a1: 79 mm; a2: 9 mm; a3: 23 mm; a4: 40 mm; a5: 17 mm; d1: 180 mm; d2: 356 mm; d3: 226 mm; d4: 123 mm; d5: 276 mm; Имя семейства: BIMLIB_Воронка_Fachmann_VMO
Размеры - Объем: 0.0167223 m3; ADSK_Диаметр условный: 160 mm; D_Листоуловитель: 164 mm; Fachmann_ВысотаВыпускногоПатрубка: 720 mm
Стадии - Стадия возведения: ПРОЕКТ
Данные - ADSK_URL документации изделия: https://kirov.fachmann-rus.ru/upload/iblock/500/500936765b1a3caa498279e0e07d3b34.pdf; ADSK_URL страницы изделия: https://kirov.fachmann-rus.ru/catalog/krovelnye-voronki/387/; ADSK_Версия Revit: 2017; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: Fachmann; ADSK_Код изделия: 22.21.21.12.1.01.04; ADSK_Количество: 1; ADSK_Марка: VMO 160x720; ADSK_Наименование: Воронка кровельная обогреваемая с обжимным металлическим фланцем и листвоуловителем VMO 160x720 (арт. 01.094); ADSK_Наименование краткое: Воронка кровельная VMO 160x720
Текст - Fachmann_Артикул: 01.094; Fachmann_МаксимальнаяТемператураВнутреннейПоверхностиВоронки: +55 °С; Fachmann_СрокСлужбы: не менее 50 лет; Fachmann_ТемператураОкружающейСреды: от -50 °С до +90 °С; Fachmann_ТемператураОтводящейЖидкости: не более +85 °С
Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 220 V; ADSK_Номинальная мощность: 30 W; ADSK_Полная мощность: 30 W; ADSK_Ток: 0.16 A
